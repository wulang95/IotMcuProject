# IAR project vc_deepsleep.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vc_deepsleep.hex
  ILINK.IlinkOutputFile: vc_deepsleep.out
  ILINK.IlinkIcfFile: HC32L07X.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: vc_deepsleep.srec
  group common
    ../../../../mcu/common/: system_hc32l07x.c interrupts_hc32l07x.c
    ./: startup_hc32l07x.s
    ../../../../driver/src/: ddl.c
  group driver
    ../../../../driver/src/: sysctrl.c vc.c gpio.c adc.c lpm.c bgr.c
  group source
    ../source/: main.c
  group README
    ../: readme.txt
