# IAR project i2s_i2c1_play_44k1.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: i2s_i2c1_play_44k1.hex
  ILINK.IlinkOutputFile: i2s_i2c1_play_44k1.out
  ILINK.IlinkIcfFile: HC32L07X.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: i2s_i2c1_play_44k1.srec
  group common
    ../../../../driver/src/: ddl.c
    ../../../../mcu/common/: interrupts_hc32l07x.c system_hc32l07x.c
    ./: startup_hc32l07x.s
  group driver
    ../../../../driver/src/: flash.c gpio.c i2c.c i2s.c sysctrl.c
  group README
    ../: Readme.txt
  group source
    ../source/: data_sound_441_i2s.c main.c
    ../../../../midware/src/: wm8731.c
