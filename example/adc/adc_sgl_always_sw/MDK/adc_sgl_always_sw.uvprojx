# Keil uVision project adc_sgl_always_sw.uvprojx, settings and files
target adc_sgl_always_sw_Release (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ESEL ELITTLE
  output: adc_sgl_always_sw +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\midware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l07x.s
    ../../../../mcu/common/: system_hc32l07x.c interrupts_hc32l07x.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c adc.c gpio.c bgr.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
