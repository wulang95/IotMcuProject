# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: HC32L072JATA HDSC
  pack: HDSC.HC32L07X.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output "@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c define: __VTOR_PRESENT = 1
  c include: ..\..\mcu\common;..\source;..\..\driver\inc;..\..\midware\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l07x.s
    ../../mcu/common/: interrupts_hc32l07x.c system_hc32l07x.c
  group source
    ../source/: main.c system.c app_ota.c
  group driver
    ../../driver/src/: flash.c gpio.c wdt.c sysctrl.c ddl.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
