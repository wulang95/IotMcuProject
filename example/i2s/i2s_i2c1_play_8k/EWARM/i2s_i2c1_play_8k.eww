<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\i2s_i2c1_play_8k.ewp</path>
  </project>
  <batchBuild/>
</workspace>


