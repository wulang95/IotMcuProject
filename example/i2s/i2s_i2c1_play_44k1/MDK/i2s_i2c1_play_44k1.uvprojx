# Keil uVision project i2s_i2c1_play_44k1.uvprojx, settings and files
target i2s_i2c1_play_44k1_Release (6120000::V6.12::.\ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ESEL ELITTLE
  output: i2s_i2c1_play_44k1 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\midware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l07x.s
    ../../../../mcu/common/: system_hc32l07x.c interrupts_hc32l07x.c
  group source
    ../source/: main.c data_sound_441_i2s.c
    ../../../../midware/src/: wm8731.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c i2s.c gpio.c i2c.c flash.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
