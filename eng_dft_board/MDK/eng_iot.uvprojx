# Keil uVision project eng_iot.uvprojx, settings and files
target eng_iot (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: HC32L072JATA HDSC
  pack: HDSC.HC32L07X.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: eng_iot +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output "@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c define: __VTOR_PRESENT = 1
  c include: ..\..\mcu\common;..\source;..\..\driver\inc;..\..\midware\src
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l07x.s
    ../../mcu/common/: interrupts_hc32l07x.c system_hc32l07x.c
  group source
    ../source/: main.c system.c FIFO.c IOT_Protol.c GPS_Control.c app_ota.c
  group driver
    ../../driver/src/: ddl.c sysctrl.c gpio.c can.c uart.c wdt.c rtc.c lpm.c flash.c dmac.c timer3.c adc.c bgr.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
